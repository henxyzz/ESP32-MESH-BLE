## sdkconfig.defaults
```kconfig
CONFIG_BT_ENABLED=y
CONFIG_BLE_MESH=y
CONFIG_BLE_MESH_PROVISIONER=y
CONFIG_BT_NIMBLE=y
CONFIG_BTDM_CTRL_MODE_BLE_ONLY=y
CONFIG_NIMBLE_MEM_ALLOC_MODE=STATIC
```
